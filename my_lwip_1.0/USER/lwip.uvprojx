# Keil uVision project lwip.uvprojx, settings and files
target LWIP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\ENC28J60;..\HARDWARE\SPI;..\lwip-1.4.1\test\unit;..\lwip-1.4.1\src\core;..\lwip-1.4.1\src\core\ipv4;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src;..\lwip-1.4.1\src\api;..\lwip-1.4.1\src\netif;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\arch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c lwipdemo.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: mysys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_spi.c
  group README
    ../: readme.txt
  group lwip_arch
    ../lwip-1.4.1/src/arch/: sys_arch.c cc.h lwipopts.h perf.h sys_arch.h cpu.h
  group lwip_core
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip_ipv4
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
